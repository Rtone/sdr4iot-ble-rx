options:
  parameters:
    author: Jan Wagner
    category: Custom
    generate_options: no_gui
    id: gr_ble
    output_language: python
    title: Bluetooth LE Receiver
  states: {}

blocks:
- name: ble_base_freq
  id: variable
  parameters:
    value: 2402e6
  states: {}
- name: ble_channel
  id: variable
  parameters:
    value: '12'
  states: {}
- name: ble_channel_spacing
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 850e3
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: durationSeconds
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable
  parameters:
    value: ble_base_freq+(ble_channel_spacing * ble_channel)
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: gmsk_gain_mu
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: gmsk_mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: gmsk_omega_limit
  id: variable
  parameters:
    value: '0.035'
  states: {}
- name: gmsk_sps
  id: variable
  parameters:
    value: int(sample_rate/data_rate)
  states: {}
- name: iq_output
  id: variable
  parameters:
    comment: Filename for I/Q output.
    value: '"ble.sigmf-data"'
  states: {}
- name: lowpass_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, sample_rate, cutoff_freq, transition_width, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: modulation_index
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: numSamples
  id: variable
  parameters:
    value: durationSeconds*sample_rate
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-70'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: analog_simple_squelch
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.1'
    threshold: squelch_threshold
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: iq_output
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(numSamples)
    type: complex
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: gmsk_sps
    sensitivity: (numpy.pi*0.5)/gmsk_sps
  states: {}
- name: freq_xlating_fir_filter_lp
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_offset'
    decim: '1'
    samp_rate: sample_rate
    taps: lowpass_filter
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: message_sink
  id: blocks_message_sink
  parameters:
    dont_block: 'True'
    type: byte
    vlen: '1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq+freq_offset
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rf_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: unpacked_to_packed
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: virtual_sink
  id: virtual_sink
  parameters: {}
  states: {}

connections:
- [analog_simple_squelch, '0', freq_xlating_fir_filter_lp, '0']
- [blocks_head_0, '0', analog_simple_squelch, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [digital_gfsk_demod_0, '0', unpacked_to_packed, '0']
- [freq_xlating_fir_filter_lp, '0', digital_gfsk_demod_0, '0']
- [message_sink, msg, virtual_sink, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [unpacked_to_packed, '0', message_sink, '0']

metadata:
  file_format: 1
